Properties of the parts of a building model (IFC4)

# File
Description: Hülsentemperaturfühler, PT 1000, 1 m, Fühlerleitung Silikon, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9030150, Hülsentemperaturfühler, PT 1000, 1 m, Fühlerleitung Silikon
In: Raum
Description: Die Hülsenfühler HF werden zur Temperaturerfassung in flüssigen oder gasförmigen Medien eingesetzt. Durch die feuchtedichte Rollierung ist der Hülsenfühler besonders gegen Feuchte und Staub geschützt. Bei Einsatz in flüssigen Medien ist der Einbau in eine Tauchhülse erforderlich.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9030150; ModelLabel: HFP 1000/S; GlobalTradeItemNumber: 4050528036032; ProductURL: https://alre.de/produkt_G9030150
Pset_Specification - NominalLength: 1 m; NominalWidth: 0.006 m; NominalDepth: 0.006 m; NetWeight: 0.044
Pset_ALRE_ETIM_Properties - Kabellänge: 1; Art der Spannungsversorgung: ohne; Geeignet für Rohrmontage: yes; Umgebungstemperatur: -50; Explosionsgeschützt: no; Schutzart (IP): IP65; Einsatzgebiet: Tauchrohr/-kanal; Geeignet für Flüssigkeiten: yes; Geeignet für Gase: yes; Temperaturmessbereich: -50; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Durchmesser Sensorelement: 6; Einstecklänge: 45; Gehäusehöhe: 6; Gehäusebreite: 6; Gehäusetiefe: 1000; Geeignet für Kanalbefestigung: yes; Festes Kabel am Sensor: yes; Material Element: rostfreier Stahl; Länge des Sensors: 45; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9030150.pdf
